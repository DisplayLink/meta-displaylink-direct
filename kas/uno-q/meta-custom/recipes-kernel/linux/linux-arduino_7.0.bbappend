FILESEXTRAPATHS:prepend := "${THISDIR}/linux-arduino:"

SRC_URI:append = " file://rtl815x.cfg"
